# Keil uVision project TXIP-SOURCE.uvprojx, settings and files
target TXIP-SOURCE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TXIP-SOURCE
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/TXIP-SOURCE.bin ./Objects/TXIP-SOURCE.axf
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Function;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport
  memory RVCT4: ROM 0x8002000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: camera_lense.c ComCmd_proc.c delay.c eeprom_i2c.c IR_uart.c main.c PT_uart.c timer.c TTl_uart.c TVC_uart.c VC_uart.c hp_conf.h
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Cmsis
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: stm32f10x_it.c system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group Fun
    ../Function/: LaserFunction.c LensDriver.c MiscAlg.c SysCfg.c Algorithm.c Preset.c Curise.c LineScan.c AppleScan.c WatchHome.c Msgqueue.c M_3d.c
